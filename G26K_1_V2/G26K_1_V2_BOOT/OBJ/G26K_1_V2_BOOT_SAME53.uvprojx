# Keil uVision project G26K_1_V2_BOOT_SAME53.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME53N19A Atmel
  pack: Atmel.SAME53_DFP.1.1.118
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G26K_1_V2_BOOT_SAME53
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
